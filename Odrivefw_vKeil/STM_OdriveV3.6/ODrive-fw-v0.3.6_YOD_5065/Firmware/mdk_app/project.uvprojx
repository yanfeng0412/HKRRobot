# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ..\project
  AfterMake: fromelf.exe --bincombined --bincombined_padding=1,0x00 --output=./output/project.bin  ./output/project.axf
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_PRINTF,INTDEF,ARM_MDK,NDEBUG,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,__GNUC__=5,USE_STDPERIPH_DRIVER,STM32F40XX,M_PI=3.1415926f __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: --gnu --c99 --cpu=Cortex-M4.fp --fpmode=fast
  c include: ..\Inc;..\MotorControl;..\Drivers\DRV8301;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\ST\STM32_USB_Device_Library\Core\inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\inc;..\Drivers\STM32F4xx_HAL_Driver\inc;..\Drivers\STM32F4xx_HAL_Driver\inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F4xx\include;..\Drivers\CMSIS\include;..\Drivers\SEGGER_RTT
  asm misc: --cpreproc --cpu=Cortex-M4.fp  --fpmode=fast
  asm include: ..\startup\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  scatter file: .\output\project_app.sct
  group Src
    ../Src/: adc.c can.c dma.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c syscalls.c system_stm32f4xx.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group MotorControl
    ../MotorControl/: low_level.c utils.c crc.c packet.c commands.c buffer.c terminal.c commands_pro.c
  group CMSIS
    ../startup/ARM/: startup_stm32f4xx.s
    ../Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group FreeRTOS/Source
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/ARM_CM4F
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group FreeRTOS/MemMang
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS/CMSIS_RTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group STM32_USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/DRV8301
    ../Drivers/DRV8301/: drv8301.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Inc
    ../Inc/: version.h
  group Drivers/SEGGER_RTT
    ../Drivers/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.0.1
